Commit message: fix fix

File: robotino/catkin_ws/src/robotino_description/robotino_zed.urdf (robot description, URDF)
Before this commit: robot robotino, 7 links, 6 joints
Joints:
- joint base_to_kinect: origin xyz=0.17 0.0 0.78 rpy=0 0 0 -> xyz=0.18 0.0 0.835 rpy=0 0 0
